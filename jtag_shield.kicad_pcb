# Repository bobc/jtag_shield

File README.md:

# About jtag_shield 

This project is a shield for Arduino Mega, which exposes a JTAG connector so that programming/debug can be performed by tools such as Atmel-ICE. The concept and a prototype build is discussed in more detail at http://www.eevblog.com/forum/microcontrollers/a-simple-'jtag-hat'-board-for-the-arduino-mega/

Designed with KiCad v4.

## KiCad design jtag_shield.kicad_pcb

Parts:
C1: 100n; C_Disc_D5.1mm_W3.2mm_P5.00mm
D1, D2: LED; LED_D3.0mm
J1: AVR-JTAG-10; PIN_ARRAY_5x2_RMC
J2: AVR-ISP-6; pin_array_3x2_RMC
Q1: BF245A; TO-92_Molded_Narrow
R1, R2: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SHIELD1: ARDUINO_MEGA_SHIELD; ARDUINO_MEGA_DUE_SHIELD_FOOTPRINT_RMC

Connections:
+5V: C1.1, D1.2 (A), D2.2 (A), J1.4 (VREF), J1.7 (VCC), J2.2 (VCC), SHIELD1.5V, SHIELD1.5V_4, SHIELD1.5V_5, SHIELD1.5V_6 (5V)
/MISO: J2.1 (MISO), SHIELD1.MISO
/MOSI: J2.4 (MOSI), SHIELD1.MOSI
/RESET: J1.6 (~SRST), J1.8 (~TRST), J2.5 (~RST), SHIELD1.RST, SHIELD1.RST2 (RST)
/SCK: J2.3 (SCK), SHIELD1.SCK
/TCK: J1.1 (TCK), SHIELD1.AD4
/TDI: J1.9 (TDI), R3.2, SHIELD1.AD7
/TDO: J1.3 (TDO), SHIELD1.AD6
/TMS: J1.5 (TMS), SHIELD1.AD5
GND: C1.2, J1.2 (GND), J1.10 (GND), J2.6 (GND), Q1.2 (S), R1.2, SHIELD1.GND, SHIELD1.GND4 (GND), SHIELD1.GND5 (GND), SHIELD1.GND6 (GND)
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1
unnamed: Q1.1 (G), R3.1
unnamed: Q1.3 (D), R2.2

Notes on the sheet:
5V SUPPLY
JTAG ACTIVITY
AD4 to AD7 are not available when JTAG is enabled
Application note: JTAG setup - Cut the RESET-EN connection to disable Auto-reset (2mm-jumper recommended) - Program the JTAGEN fuse to enable the JTAG test access port/TAP

Board: 2 copper layers, 10 parts (0 on the bottom side), 14 nets, no tracks yet.

## Commit log

2018-02-08 Don't need autosave file in git
2018-02-10 Updated with changes from Magnus
